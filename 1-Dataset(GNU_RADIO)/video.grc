options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: channel_dataset
    output_language: python
    title: channel_dataset_4qam
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '45'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '188'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.00628'
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tuning
  id: variable
  parameters:
    value: 1000e3
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/rodrigo/Documents/Amplificado/4QAM/sent
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/rodrigo/Documents/Amplificado/4QAM/received
    type: complex
  states: {state: disabled}
- name: blocks_head_0_0_0
  id: blocks_head
  parameters:
    num_items: int(samples)
    type: complex
  states: {state: disabled}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1000'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    type: byte
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    len_tag_key: '"packet_len"'
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '1234'
    src_zeros: 'False'
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    color1: '"green"'
    grid: 'True'
    gui_hint: 0,1,2,1
    label1: rec
    size: '4098'
    type: complex
    update_time: '0.1'
    xmax: '1.0'
    xmin: '-1.0'
    ymax: '1.0'
    ymin: '-1.0'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    gain: '0.7'
    interp: sps
    ntaps: nfilts
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: interp_fir_filter_ccf
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: tuning
    clock_source0: external
    dev_addr: '"addr0=192.168.10.2"'
    gain0: rf_gain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate/2
    center_freq0: tuning
    clock_source0: external
    dev_addr: '"addr0=192.168.10.3"'
    dev_args: '""'
    gain0: rf_gain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_head_0_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_multiply_const_vxx_1, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', blocks_head_0_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [network_udp_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [root_raised_cosine_filter_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_const_vxx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
